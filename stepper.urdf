Commit message: feat:fied directioning

File: stepper.urdf (robot description, URDF)
Before this commit: robot stepper_robot, 2 links, 1 joints
Joints:
- joint stepper_joint: limit lower=-3.14159 upper=3.14159 effort=1.0 velocity=1.0 -> lower=-6.14159 upper=6.14159 effort=1.0 velocity=1.0
